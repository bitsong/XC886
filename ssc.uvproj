# Keil uVision project ssc.uvproj, settings and files
target Target 1 (MCS-51)
  device: XC886CLM-8FF Infineon
  cpu: IRAM(0-0xFF) XRAM(0xF000-0xF5FF) IROM(0-0x5FFF) IROM2(0xA000-0xBFFF) CLOCK(24000000) MOD517DP
  output: ssc +hex
  c flags: Optimize=8 SizeSpeed=1
  group Dave Files
    ./: START_XC.a51 MAIN.C IO.C SSC.C T01.C
  group User Files
    ./: message.c message.h
